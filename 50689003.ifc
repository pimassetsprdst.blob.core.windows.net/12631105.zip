Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-21T17:46:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 21 17:46:02 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{7966C3EE-175F-40A4-8994-28315A4FF304}\ifc * Database version: 5507 * Database creation date: Wed Aug 21 17:46:02 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 21 17:46:02 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 21 17:46:02 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 50689003 Cover part for shower faucet, 50689003:50689003 Cover part for shower faucet:418803
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 89.7 mm; NominalHeight: 130.2 mm; NominalWidth: 90 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 50689003; ConvergoRefNr: 0087-1909-0065-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 19/07/2019
Type - Green Building Properties(Type) - Customs Code: 84819000; EAN Number: 4057304012501; EN Standard: EN 817
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.hansa.com/bim/50689003; Catalog Drawing URL: http://static.hansa.com/catdrw/50689003; Class: Single lever, trim kit; Dimension Drawing URL: http://static.hansa.com/dimdrw/50689003; FDV Document URL: http://www.hansa.com/datasheet/50689003/en/fdv; Group: Shower faucets; Manufacturer: Hansa; Model: 50689003 Cover part for shower faucet; Name_en: 50689003 Cover part for shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 164 x 114 x 68; Package Weight: 0.603 kg; Product Code: 50689003; Product Datasheet: http://www.hansa.com/datasheet/50689003/en; Product Family: HANSADESIGNO; Product Image URL: http://static.hansa.com/image/50689003; Product URL: http://static.hansa.com/50689003; Type Name: 50689003 Cover part for shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Installation and Maintenance: http://static.hansa.com/manual/50689003; Installation Type: Wall mounted for concealed unit; Lever Handle: Single operating lever; Max. Hot Water Supply: 80 kg/K/s3; Spare Parts: http://static.hansa.com/sp/50689003
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 50689003; Features: Single lever, trim kit; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 50689003; Name: 50689003 Cover part for shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 90x90x130 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 50689003; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 50689003 Cover part for shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0314574 m2; Volume: 0.00105048 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 50689003: 50689003 Cover part for shower faucet; Family and Type: 50689003: 50689003 Cover part for shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 50689003: 50689003 Cover part for shower faucet; Type Id: 50689003: 50689003 Cover part for shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
